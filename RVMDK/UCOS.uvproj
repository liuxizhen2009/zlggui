# Keil uVision project UCOS.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: crscmb +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../User/: main.c UASRT_Isr.c AppTask.c GuiProc.c SimKeyLayer.c Menu_test.c
    ../User/KEY_MN/: KEY.C
  group Command
    ../Command/: Command.c CommandParse.c
  group UCOSII
    ../UCOSII/: os_core.c os_cpu_c.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_cfg.h os_cpu.h os_cpu_a.asm ucos_ii.h
    ../UCOSII/API/: os_api.c
  group HAL
    ../Hal/: GPIO.c hal.c nvic.C RCC.c stm32f10x_it.c USART.c Timer.c Audio.c LED.c
  group Logger
    ../Logger/: debug.c Debug.h err.h printf.c printf.h
  group STM32Lib
    ../STM32lib/: stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c
    ../STM32lib/StartUp/: startup_stm32f10x_hd.s
  group ZLGGUI
    ../ZLG_GUI/: ConvertColor.c font5_7.c FONT8_8.C FONT24_32.C GUI_BASIC.C GUI_StockC.C guilcddriver.c jlxlcddriver.c loadbit.c menu.c spline.c windows.c
